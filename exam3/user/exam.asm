ORG 0000H
LJMP INIT
ORG 0003H
LJMP INTERRU0
ORG 0013H
LJMP INTERRU1

ORG 0030H
INIT:	SETB IT0
	SETB IT1
	SETB EX0
	SETB EX1
	SETB EA
	
START:	MOV R1,#00H
	MOV R2,#9
	MOV DPTR,#TABLE
MAIN:	MOV A,R1
	MOVC A,@A+DPTR
	MOV P0,A
	CALL TIMEMUL	;调用要时函数
	DJNZ R2,NEXTNUM
	SJMP START

TIMEMUL:MOV R3,#20
DELAY:	MOV R7,#200
DELAY1:	MOV R6,#125
DELAY2:	DJNZ R6,DELAY2
	DJNZ R7,DELAY1
	DJNZ R3,DELAY	;一秒钟
	RET

NEXTNUM:INC R1
	SJMP MAIN

INTERRU0:
	PUSH A
	PUSH R1
	PUSH R2
	;unfinished
	;
	MOV P2,#0a4H
	RETI
INTERRU1:
	RETI

TABLE:DB 0xc0, 0xf9, 0xa4, 0xb0,0x99, 0x92, 0x82, 0xf8
END	
